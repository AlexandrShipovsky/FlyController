# IAR project FlyController.ewp, settings and files
configuration FlyController (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F767xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ..\libraries\CLI; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ..\libraries\common; ..\Drivers\BSP\Components\a3g4250d; ..\Drivers\BSP\Components\h3lis331dl; ..\Drivers\BSP\Components\lis3mdl; ..\Drivers\BSP\Components\lps331; ../Middlewares/ST/STM32_MotionFX_Library/Inc; ../Middlewares/ST/STM32_MotionVC_Library/Inc; ../Middlewares/ST/STM32_MotionMC_Library/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: FlyController.hex
  ILINK.IlinkOutputFile: FlyController.out
  ILINK.IlinkIcfFile: stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../Src/: IMU.c main.c freertos.c lwip.c ethernetif.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f7xx_nucleo_bus.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lis3mdl/: lis3mdl_reg.h lis3mdl.h lis3mdl_reg.c lis3mdl.c
    ../Drivers/BSP/Components/h3lis331dl/: h3lis331dl_reg.h h3lis331dl.h h3lis331dl_reg.c h3lis331dl.c
    ../Drivers/BSP/Components/a3g4250d/: a3g4250d_reg.h a3g4250d.h a3g4250d_reg.c a3g4250d.c
  group Drivers/BSP/Components/a3g4250d
    ../Drivers/BSP/Components/a3g4250d/: a3g4250d.c a3g4250d.h a3g4250d_reg.c a3g4250d_reg.h
  group Drivers/BSP/Components/h3lis331dl
    ../Drivers/BSP/Components/h3lis331dl/: h3lis331dl.c h3lis331dl.h h3lis331dl_reg.c h3lis331dl_reg.h
  group Drivers/BSP/Components/lis3mdl
    ../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl.h lis3mdl_reg.c lis3mdl_reg.h
  group Drivers/BSP/Components/lps331
    ../Drivers/BSP/Components/lps331/: lps331.c lps331.h lps331_reg.c lps331_reg.h
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_can.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group libraries/CLI
    ../libraries/CLI/: cli.cpp cli.h cli_base.h cli_cmd.cpp cli_cmd.h cli_config.h cli_port.cpp cli_port.h
  group libraries/common
    ../libraries/common/: confighawk.h prothawk.c prothawk.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/MEMS/Motion Library/MotionFX
    ../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM7F_wc32_ot.a
    ../Middlewares/ST/STM32_MotionFX_Library/Inc/: motion_fx.h motion_fx_cm0p.h
  group Middlewares/MEMS/Motion Library/MotionMC
    ../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM7F_wc32_ot.a
    ../Middlewares/ST/STM32_MotionMC_Library/Inc/: motion_mc.h motion_mc_cm0p.h
  group Middlewares/MEMS/Motion Library/MotionVC
    ../Middlewares/ST/STM32_MotionVC_Library/Lib/: MotionVC_CM7F_wc32_ot.a
    ../Middlewares/ST/STM32_MotionVC_Library/Inc/: motion_vc.h
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
